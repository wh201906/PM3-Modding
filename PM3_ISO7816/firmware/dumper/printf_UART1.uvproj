# Keil uVision project printf_UART1.uvproj, settings and files
target GPIO (MCS-51)
  device: N76E003 Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x47FF)  XRAM(0 - 0x2FF) CLOCK(16000000)
  output: Printf_UART1 +hex
  AfterMake: .\hex2bin.exe .\output\*.hex
  c flags: Optimize=8
  c define: FOSC_160000
  c include: ..\..\Include;.\Include
  group Source Group 1
    ./Code/: Print_UART1.C PUTCHAR.C
  group Common
    ./Common/: Common.c Delay.c
  group Startup
    ./Startup/: STARTUP.A51
